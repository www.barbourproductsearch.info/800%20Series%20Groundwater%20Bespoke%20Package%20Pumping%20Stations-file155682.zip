Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-24T14:12:35
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection
4 x Port_326837 | SINK
Port_326837 | SOURCE

# IfcFlowMovingDevice: NBS_DeltaMembraneSystemsLtd_PckgdPmpngStion_Delta800SeriesBespokePackagedPumpStationGroundwater:DualV3GroundwaterDMS-E001800.1250, NBS_DeltaMembraneSystemsLtd_PckgdPmpngStion_Delta800SeriesBespokePackagedPumpStationGroundwater:DualV3GroundwaterDMS-E001800.1250:326837
In: Level 0
Type - Classification: Pr_70_55_76_62 (Uniclass2015); Material: NBS_DeltaMembraneSystemsLtd_Plastic_White, NBS_DeltaMembraneSystemsLtd_Plastic_Black (4), NBS_DeltaMembraneSystemsLtd_Polyethylene (5)
Type - IFC - IfcExportAs: IfcPumpType; IfcExportType: SUBMERSIBLEPUMP
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_55_76_62:Packaged pumping stations; Color: n/a; Finish: n/a; Material: High density polyethylene (HDPE); Shape: Other; Size: n/a; WarrantyDescription: One year; CodePerformance: n/a; Constituents: n/a; Description: Delta Bespoke 800 Series Groundwater Package Pumping Station are available in depths from 1250 mm to 2000 mm and with varying pumping capabilities from the Delta V3 to powerful Delta Dual V6 pump.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Delta 800 Series Bespoke Packaged Pump Station (Groundwater); Name: PackagedPumpingStations_Delta800SeriesBespokePackagedPumpStationGroundwater_DualV3GroundwaterDMS-E001800.1250_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_PackagedPumpingStations_Delta800SeriesBespokePackagedPumpStationGroundwater_DualV3GroundwaterDMS-E001800.1250; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/5d5000f6-8e0e-da53-8f40-15f200882027/4a7e3157-b6e8-418c-9dd9-470e278d8157; Uniclass2015Code: Pr_70_55_76_62; Uniclass2015Title: Packaged pumping stations; Uniclass2015Version: Products v1.35; Version: 10
Type - NBS_Data - CollectionTankMaterial: Polyethylene; PumpsConfiguration: Twin pumps; ConnectionsInletDiameter: DN 110; ConnectionsVentPipesMaterial: PVC; ConnectionsVentPipesDiameter: DN 110; ContainsRedListMaterials: No; CountryOfProductManufacture: United Kingdom; Material: High density polyethylene (HDPE); Recyclability: Yes; RecycledContent: 0; Dimensions: Ø800 x 1250 mm; Pump: V3
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
